Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2022-10-06T11:27:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.5.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 06 11:27:50 2022 * Host: HPZ2-TPLAT * Database: C:\Users\TESSAP~1\AppData\Local\Temp\{80BC49A2-7B94-4418-985E-B9067C8C9F52}\ifc * Database version: 5507 * Database creation date: Thu Oct 06 11:27:50 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 06 11:27:50 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 06 11:27:50 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\7. Oplegmaterialen\50-Oplegmaterialen constructief; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\7. Oplegmaterialen\50-Oplegmaterialen constructief; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcBuildingElementProxy: Artikelgroep | Article group 5015, NLRSnl_ 28_GM_WPB_5015-Menhir F-150_Mavotrans_R19:Menhir F150_100:344869
In: Level 0
Type - Description: Menhir F-150 - 100mm; Classification: 28 (Default Classification); Material: Plastic, Opaque Beige (4), Rubber, neoprene (2), Plastic, Opaque Black (2), Silicon grease
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Dikte | Thickness (mm): 5 mm; Height: 5 mm
Type - Fire Protection - Brandwerendheid | Fire resistance rating: Niet getest | Not rated
Type - Forces - Belasting (UGT) | Load (Ultimate Limite State) +10/-10: 1.800 kN; Belasting (UGT) | Load (Ultimate Limite State) +20/-20: 1.600 kN; Wrijvingscoëfficent | Coefficient of friction (µ): ≤ 0,1
Type - General - Temperatuurbestendigheid | Temperature resistence: -30°C to 60°C
Type - Identity Data - Artikelnummer | Article number: Artikelgroep | Article group 5015; Beschrijving | Description: Menhir F-150 - 100mm; Laatste versie | Last version: 06-10-2022; Leverancier | Supplier: Mavotrans; Model: LOD400; NL-SfB code: 28; Opmerkingen | Comments: Horizontale verplaatsing maximaal +20/-20 mm, maximale breedte is 1000 mm | Horizontal displacement up to -20/+20 mm, maximum width 1000 mm; Revisie | Revision: Rev0; Technische data | Technical data: Raadpleeg de gekoppelde webpagina | Please refer to linked URL; Tekenaar | Draftsman: D. Blokland; Type Name: Menhir F150_100; URL: https://mavotrans.nl/menhir-f-150-glijfolie.html; Verpakkingshoeveelheid | Sales packaging: 1 stuk van 1,0 meter lengte | 1 length of 1,0 m; Voorwaarden | Disclaimer: Raadpleeg de gekoppelde webpagina en controleer voor gebruik van dit BIM-model op de laatst beschikbare revisie. De modellen, geometrie, data en parameterwaarden zijn met de grootste zorg bepaald. Desalniettemin bestaat de mogelijkheid op onjuistheden. Elke aansprakelijkheid hiervoor wordt van de hand gewezen, hoewel melding op prijs wordt gesteld. © Mavotrans, 2022 | Please refer to linked URL and check for the latest available model revision. The models, geometry and parameter values have been determined with the greatest care. Still, they are subject to errors. Mavotrans cannot be held liable in any way. However, we do appreciate your feedback. © Mavotrans, 2022
Type - Materials and Finishes - Materiaal | Material: Neopreen rubber | Neoprene rubber
Type - Other - Category: Generic Models; Family Name: NLRSnl_ 28_GM_WPB_5015-Menhir F-150_Mavotrans_R19; W: 100 mm
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_ProvisionForVoid - Height: 5 mm
Pset_BuildingElementProxyCommon - Reference: NLRSnl_ 28_GM_WPB_5015-Menhir F-150_Mavotrans_R19:Menhir F150_100; sets with these values: 2
Pset_ProvisionForVoid - Width: 100 mm; Depth: 2 mm
Constraints - Level: Level: Level 0; Offset: 0 mm; Work Plane: Level : Level 0
Dimensions - Area: 0.0845 m2; Breedte | Width (mm): 100 mm; Lengte | Length (mm): 800 mm; Volume: 0.0004 m3
Other - 0.5 H: 2.5 mm; Family: NLRSnl_ 28_GM_WPB_5015-Menhir F-150_Mavotrans_R19: Menhir F150_100; Family and Type: NLRSnl_ 28_GM_WPB_5015-Menhir F-150_Mavotrans_R19: Menhir F150_100; H1: 2 mm; Length: 800 mm; Schedule Level: Level: Level 0; Type: NLRSnl_ 28_GM_WPB_5015-Menhir F-150_Mavotrans_R19: Menhir F150_100; Type Id: NLRSnl_ 28_GM_WPB_5015-Menhir F-150_Mavotrans_R19: Menhir F150_100; Width: 100 mm
Phasing - Phase Created: New Construction
